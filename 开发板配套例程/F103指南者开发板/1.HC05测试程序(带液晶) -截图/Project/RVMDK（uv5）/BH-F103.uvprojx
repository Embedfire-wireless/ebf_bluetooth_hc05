# Keil uVision project BH-F103.uvprojx, settings and files
target HC05 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HC05 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\BMP;..\..\User\ff9;..\..\User\sdcard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/hc05/: bsp_hc05.c
    ../../User/led/: bsp_led.c
    ../../User/Key/: bsp_key.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/font/: fonts.c
    ../../User/usart/: bsp_usart.c bsp_usart_blt.c
    ../../User/BMP/: bsp_bmp.c
    ../../User/ff9/: diskio.c ff.c
    ../../User/ff9/option/: cc936.c
    ../../User/sdcard/: bsp_sdfs_app.c bsp_sdio_sdcard.c
  group DOC
    ../../Doc/: 【必读】程序说明.txt
